# IAR project CRC_Data_Reversing_16bit_CRC.ewp, settings and files
configuration CRC_Data_Reversing_16bit_CRC (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL3RKB ST STM32WL3RKB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NUCLEO_WL3RKB; USE_HAL_DRIVER; STM32WL3RX
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc; ../../../../../../Drivers/STM32WL3x_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32WL3X/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WL3R-Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CRC_Data_Reversing_16bit_CRC.hex
  ILINK.IlinkOutputFile: CRC_Data_Reversing_16bit_CRC.out
  ILINK.IlinkIcfFile: stm32wl3rx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wl3rx.s
  group Application/User
    ../Src/: main.c stm32wl3x_it.c stm32wl3x_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WL3R-Nucleo
    ../../../../../../Drivers/BSP/STM32WL3R-Nucleo/: stm32wl3r_nucleo.c
  group Drivers/STM32WL3x_HAL_Driver
    ../../../../../../Drivers/STM32WL3x_HAL_Driver/Src/: stm32wl3x_hal_cortex.c stm32wl3x_hal_rcc.c stm32wl3x_hal_rcc_ex.c stm32wl3x_hal_flash.c stm32wl3x_hal_flash_ex.c stm32wl3x_hal_gpio.c stm32wl3x_hal_dma.c stm32wl3x_hal_pwr.c stm32wl3x_hal_pwr_ex.c stm32wl3x_hal.c stm32wl3x_hal_crc.c stm32wl3x_hal_crc_ex.c stm32wl3x_hal_tim.c stm32wl3x_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wl3x.c
